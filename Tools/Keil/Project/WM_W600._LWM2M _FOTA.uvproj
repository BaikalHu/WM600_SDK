# Keil uVision project WM_W600._LWM2M _FOTA.uvproj, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: WM_W600 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: makeimg.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: WM_W600,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,WITH_LWIP,WITH_LWM2M,LWM2M_CLIENT_MODE,LWM2M_LITTLE_ENDIAN,CONFIG_FEATURE_FOTA,
  c misc: --c99 --gnu
  c include: ..\..\..\Include;..\..\..\Src\Network\api;..\..\..\Src\Wlan\Driver;..\..\..\Src\Wlan\Supplicant;..\..\..\Platform\Common\Params;..\..\..\Platform\Common\task;..\..\..\Platform\Common\mem;..\..\..\Platform\Common\fwup;..\..\..\Platform\Common\utils;..\..\..\Platform\Inc;..\..\..\Platform\Sys;..\..\..\Src\App\wm_atcmd;..\..\..\Src\App\demo;..\..\..\Src\App\dhcpserver;..\..\..\Src\App\dnsserver;..\..\..\Src\App\matrixssl;..\..\..\Src\App\matrixssl\crypto;..\..\..\Src\App\libupnp-1.6.19\ixml\inc;..\..\..\Src\App\libupnp-1.6.19\upnp\inc;..\..\..\Src\App\libupnp-1.6.19\ixml\include;..\..\..\Src\App\libupnp-1.6.19\threadutil\include;..\..\..\Src\App\libupnp-1.6.19\upnp\include;..\..\..\Src\App\gmediarender-0.0.6;..\..\..\Src\App\web;..\..\..\Src\App\cloud;..\..\..\Src\App\cJSON;..\..\..\Src\App\ajtcl-15.04.00a\inc;..\..\..\Src\App\ajtcl-15.04.00a\target\winnermicro;..\..\..\Src\App\ajtcl-15.04.00a\external\sha2;..\..\..\Src\App\cloud\Kii;..\..\..\Src\App\rmms;..\..\..\Demo;..\..\..\Src\App\ntp;..\..\..\Src\OS\OS_ports;..\..\..\Src\App\httpclient;..\..\..\Src\App\oneshotconfig;..\..\..\Lib;..\..\..\Src\App\iperf;..\..\..\Platform\Common\crypto;..\..\..\Include\App;..\..\..\Include\Driver;..\..\..\Include\Net;..\..\..\Include\OS;..\..\..\Include\Platform;..\..\..\Include\WiFi;..\..\..\Src\App\matrixssl\core;..\..\..\Platform\Common\crypto\digest;..\..\..\Platform\Common\crypto\math;..\..\..\Platform\Common\crypto\symmetric;..\..\..\Src\App\mqtt;..\..\..\Src\App\iperf;..\..\..\Src\App\ping;..\..\..\Src\App\polarssl\include;..\..\..\Src\App\mDNS\mDNSPosix;..\..\..\Src\App\mDNS\mDNSCore;..\..\..\Src\Network\lwip2.0.3\include;..\..\..\Src\App\OTA;..\..\..\Src\App\libwebsockets-2.1-stable;..\..\..\Src\OS\LiteOS\arch\arm\arm-m\include;..\..\..\Src\OS\LiteOS\arch\arm\common\cmsis;..\..\..\Src\OS\LiteOS\arch\arm\arm-m\cortex-m3;..\..\..\Src\OS\LiteOS\kernel\include;..\..\..\Src\OS\LiteOS\kernel\base\include;..\..\..\Src\OS\LiteOS\kernel\extended\include;..\..\..\Src\OS\LiteOS\OS_CONFIG;..\..\..\Src\Atiny\security\mbedtls\mbedtls-2.6.0\include;..\..\..\Src\Atiny\agent_tiny\atiny_mqtt;..\..\..\Src\Atiny\include;..\..\..\Src\Atiny\include\sal;..\..\..\Src\Atiny\include\osdepends;..\..\..\Src\Atiny\include\log;..\..\..\Src\Atiny\mqtt\mqtt_paho\mqtt_paho\MQTTClient-C\src;..\..\..\Src\Atiny\security\mbedtls\mbedtls_port;..\..\..\Src\Atiny;..\..\..\Src\Atiny\cJSON;..\..\..\Src\Atiny\demos\agenttiny_lwm2m;..\..\..\Src\Atiny\agent_tiny\atiny_lwm2m;..\..\..\Src\Atiny\lwm2m\core\er-coap-13;..\..\..\Src\Atiny\lwm2m\core;..\..\..\Src\Atiny\ota\flag_operate;..\..\..\Src\Atiny\lwm2m\examples\shared;..\..\..\Src\Atiny\ota\utility;..\..\..\Src\Atiny\ota\package;..\..\..\Src\Atiny\ota\ota_port
  asm include: ..\..\..\Include\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8010100 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x380000
  group main
    ../../../App/: main.c
  group Platform
    ../../../Platform/Boot/armcc/: startup_venus.s retarget.c misc.c
    ../../../Platform/Sys/: wm_main.c tls_sys.c
    ../../../Platform/Drivers/: wm_driver.c
    ../../../Platform/Common/: wm_common.c
    ../../../Src/OS/LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group demo
    ../../../Demo/: wm_uart_demo.c wm_gpio_demo.c wm_flash_demo.c wm_pwm_demo.c wm_master_spi_demo.c wm_rtc_demo.c wm_timer_demo.c wm_pmu_demo.c wm_crypt_hard_demo.c wm_rsa_demo.c wm_socket_client_demo.c wm_connect_net_demo.c wm_apsta_demo.c wm_softap_demo.c wm_ntp_demo.c wm_udp_demo.c wm_socket_server_demo.c wm_wps_demo.c wm_http_demo.c wm_i2c_demo.c wm_i2s_demo.c wm_websockets_demo.c wm_slave_spi_demo.c wm_ssl_server_demo.c wm_scan_demo.c wm_adc_demo.c wm_7816_demo.c
    ../../../Demo/console/: wm_demo_console_task.c
  group DhcpServer
    ../../../Src/App/dhcpserver/: dhcp_server.c
  group DnsServer
    ../../../Src/App/dnsserver/: dns_server.c
  group oneshotcfg
    ../../../Src/App/oneshotconfig/: wm_wifi_oneshot.c wm_oneshot_airkiss.c libairkiss_log.lib wm_oneshot_lsd.c
  group Cmd
    ../../../Src/App/wm_atcmd/: wm_cmd.c
  group OS
    ../../../Src/OS/LiteOS/: wm_osal_liteos.c wm_rtos.c
  group LWIP
    ../../../Src/Network/: lwip2.0.3.c lwip.c
  group NTP
    ../../../Src/App/ntp/: ntp_client.c
  group websocket
    ../../../Src/App/libwebsockets-2.1-stable/: base64-decode.c client.c client-handshake.c client-parser.c context.c handshake.c header.c libwebsockets.c lws-plat-wm.c output.c parsers.c pollfd.c service.c ssl.c ssl-client.c
  group HttpClient
    ../../../Src/App/httpclient/: wm_http_compile.c
  group PING
    ../../../Src/App/ping/: ping.c
  group MatrixSSL
    ../../../Src/App/matrixssl/: wm_matrixssl_compile.c
  group Iperf
    ../../../Src/App/iperf/: iperf_api.c iperf_client_api.c iperf_error.c iperf_locale.c iperf_main.c iperf_net.c iperf_server_api.c iperf_tcp.c iperf_timer.c iperf_udp.c iperf_units.c iperf_util.c tcp_info.c tcp_window_size.c wm_perf.c
  group mDNS
    ../../../Src/App/mDNS/mDNSPosix/: mDNSPosix.c
    ../../../Src/App/mDNS/mDNSCore/: mDNS.c
  group wlan_lib
    ../../../Lib/Wlan/: wlan.lib
  group OTA
    ../../../Src/App/OTA/: wm_http_fwup.c wm_socket_fwup.c
  group SSLServer
    ../../../Src/App/sslserver/: wm_ssl_server.c
  group WebServer
    ../../../Src/App/web/: fs.c httpd.c web.c
  group Atiny_LWM2M
    ../../../Src/Atiny/agent_tiny/atiny_lwm2m/: agenttiny.c atiny_rpt.c connection.c firmware_update.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c util_timer.c atiny_fota_manager.c atiny_fota_state.c
    ../../../Src/Atiny/libc/: errno.c malloc.c
    ../../../Src/Atiny/log/: atiny_log.c
    ../../../Src/Atiny/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c lwm2m_utils.c management.c objects.c observe.c registration.c tlv.c transaction.c uri.c packet.c
    ../../../Src/Atiny/lwm2m/core/er-coap-13/: er-coap-13.c
    ../../../Src/Atiny/sal/: atiny_socket.c
    ../../../Src/Atiny/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
    ../../../Src/Atiny/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../Src/Atiny/demos/agenttiny_lwm2m/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
    ../../../Src/Atiny/: atiny_osdep.c
    ../../../Src/Atiny/ota/flag_operate/: flag_manager.c upgrade_flag.c
    ../../../Src/Atiny/ota/utility/: ota_crc.c
    ../../../Src/Atiny/lwm2m/examples/shared/: commandline.c
    ../../../Src/Atiny/ota/ota_port/: ota_port.c
    ../../../Src/Atiny/ota/package/: package.c package_checksum.c package_head.c package_writer.c
